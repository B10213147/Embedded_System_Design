# Keil uVision project ex4.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ex4
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER
  c include: C:\st\STM32Cube_FW_F0_V1.6.0\Drivers\STM32F0xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./: main.c
  group HAL_Driver
    C:/st/STM32Cube_FW_F0_V1.6.0/Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_gpio.c
software components: CMSIS:CORE 4.3.0, Device:Startup 2.2.3
